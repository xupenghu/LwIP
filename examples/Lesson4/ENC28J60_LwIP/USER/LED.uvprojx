# Keil uVision project LED.uvprojx, settings and files
target LwIP (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\ENC28J60;..\HARDWARE\SPI;..\lwip-STABLE-1_4_1\src\api;..\lwip-STABLE-1_4_1\src\arch;..\lwip-STABLE-1_4_1\src\include;..\lwip-STABLE-1_4_1\src\netif;..\lwip-STABLE-1_4_1\src\include\ipv4;..\lwip-STABLE-1_4_1\src;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\IIC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c lwip_demo.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/IIC/: myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_exti.c
  group lwip/netif
    ../lwip-STABLE-1_4_1/src/netif/: etharp.c ethernetif.c slipif.c
  group lwip/arch
    ../lwip-STABLE-1_4_1/src/arch/: cc.h lwipopts.h perf.h
  group lwip/core
    ../lwip-STABLE-1_4_1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/core/ipv4
    ../lwip-STABLE-1_4_1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group README
    ../: readme.txt
